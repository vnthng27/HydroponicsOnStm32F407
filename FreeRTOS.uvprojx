# Keil uVision project FreeRTOS.uvprojx, settings and files
target Freertos (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FreeRTOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000,USE_FULL_ASSERT
  c include: .\CMSIS\Include;.\CMSIS;.\FreeRTOS;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM4F;.\Startup;.\Std_PeriphDriver\inc;.\Std_PeriphDriver\src;.\User;.\FreeRTOS\portable\MemMang;.\RTC_I2C\Inc;.\RTC_I2C\Src;.\OneWireLib
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: main.c main.h ConfigForRTOS.h
    ./FreeRTOS/include/: FreeRTOSConfig.h
  group Startup
    ./Startup/: startup_stm32f40_41xxx.s
  group CMIS
    ./CMSIS/: system_stm32f4xx.c stm32f4xx.h stm32f4xx_it.c stm32f4xx_it.h
  group Std_PeriphDriver
    ./Std_PeriphDriver/src/: stm32f4xx_gpio.c stm32f4xx_adc.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_exti.c stm32f4xx_syscfg.c
    ../FreeRTOS/Std_PeriphDriver/src/: stm32f4xx_dma.c misc.c stm32f4xx_i2c.c stm32f4xx_tim.c
  group FreeRTOS
    ./FreeRTOS/: croutine.c list.c queue.c tasks.c timers.c
    ./FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
  group RTC
    ./RTC_I2C/Src/: rtc_i2c.c rtc_usart.c rtc_ds1307.c
  group DS18B20
    ./OneWireLib/: ds18b20_mflib.c
